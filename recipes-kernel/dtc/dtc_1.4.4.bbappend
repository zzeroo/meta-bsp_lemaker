

DEPENDS += "swig swig-native"


