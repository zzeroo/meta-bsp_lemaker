hostname = "xmz-mod-touch_${MACHINE}"
