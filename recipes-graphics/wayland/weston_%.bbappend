
EXTRA_OECONF_append_bananapro = "\
		WESTON_NATIVE_BACKEND=fbdev-backend.so \
		"