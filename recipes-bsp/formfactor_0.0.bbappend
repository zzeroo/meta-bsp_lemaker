HAVE_TOUCHSCREEN=1
HAVE_KEYBOARD=0

DISPLAY_CAN_ROTATE=0
DISPLAY_ORIENTATION=0
DISPLAY_WIDTH_PIXELS=1024
DISPLAY_HEIGHT_PIXELS=600
